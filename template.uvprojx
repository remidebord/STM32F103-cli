# Keil uVision project template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp
  c include: .\inc;.\lib\api\inc;.\lib\cmsis\inc;.\lib\system\inc;.\lib\misc\inc;.\lib\usb;.\lib\usb\STM32_HAL;.\lib\usb\STM32_HAL\Inc;.\lib\usb\STM32_USB_Device_Library\Class\CDC\Inc;.\lib\usb\STM32_USB_Device_Library\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group system
    ./lib/system/src/: startup_stm32f103xb.S system_stm32f1xx.c stm32f1xx_it.c
  group cmsis
    ./lib/cmsis/inc/: cmsis.h cmsis_nvic.h core_cm3.h
  group usb
    ./lib/USB/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
    ./lib/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./lib/USB/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ./lib/USB/STM32_HAL/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c
  group api
    ./lib/api/src/: Common.c CircularBuffer.cpp Delay.c GPIO.cpp Digital.cpp Timer.cpp Analog.cpp Serial.cpp USB.cpp
  group user
    ./src/: main.c CLI.cpp
